# Keil uVision project io_2eth_stm32f4.uvprojx, settings and files
target io_2eth_stm32f4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: io_2eth_stm32f4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LWIP_DEBUG
  c include: ../Inc;                ../Middlewares/Third_Party/LwIP/src/include;                ../Middlewares/Third_Party/LwIP/system;                ../Drivers/STM32F4xx_HAL_Driver/Inc;                ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                ../Middlewares/Third_Party/FreeRTOS/Source/include;                ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                ../Middlewares/Third_Party/LwIP/src/include/lwip;                ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;                ../Middlewares/Third_Party/LwIP/src/include/netif;                ../Middlewares/Third_Party/LwIP/src/include/posix;                ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                ../Middlewares/Third_Party/LwIP/system/arch;                ../Drivers/CMSIS/Include;                ..\Middlewares\Third_Party\modbus\include;                ..\Middlewares\Third_Party\modbus\port;                ..\Middlewares\Third_Party\modbus\tcp
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: ethernetif.c freertos.c stm32f4xx_hal_msp.c main.c lwip.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c di_monitor.c ai_monitor.c modbus_tcp_server.c sh_z_init.c
    ../Middlewares/Third_Party/modbus/port/: portevent.c portother.c porttcp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_spi.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c ethernet.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: icmp6.c ethip6.c ip6.c ip6_addr.c ip6_frag.c inet6.c nd6.c mld6.c dhcp6.c
    ../Middlewares/Third_Party/LwIP/src/core/: inet_chksum.c udp.c tcp_in.c sys.c def.c ip.c mem.c tcp_out.c tcp.c init.c timeouts.c dns.c pbuf.c netif.c memp.c raw.c stats.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c sockets.c err.c tcpip.c netifapi.c api_msg.c netdb.c netbuf.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: chap-md5.c pppol2tp.c magic.c ipcp.c ipv6cp.c mppe.c multilink.c ppp.c demand.c eui64.c chap-new.c upap.c pppapi.c pppos.c pppcrypt.c ccp.c vj.c lcp.c pppoe.c auth.c ecp.c eap.c chap_ms.c fsm.c utils.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_frag.c etharp.c ip4_addr.c dhcp.c igmp.c autoip.c ip4.c icmp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c tasks.c list.c timers.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Middlewares/modbus
    ../Middlewares/Third_Party/modbus/: mb.c
    ../Middlewares/Third_Party/modbus/tcp/: mbtcp.c
    ../Middlewares/Third_Party/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
software components: CMSIS:CORE 5.1.1, Compiler:I/O:STDERR 1.4.0, Compiler:I/O:STDIN 1.4.0, Compiler:I/O:STDOUT 1.4.0
